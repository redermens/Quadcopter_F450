# Keil uVision project F450.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.5.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: cvboard_prg +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,ARM_MATH_CM4,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING,__FPU_PRESENT=1,__FPU_USED=1,__CC_ARM,USE_USB_OTG_FS
  c include: .\User;.\FWLibrary\inc;.\Hardware\inc;.\Fatfs;.\Usb\STM32_USB_OTG_Driver\inc;.\Usb\STM32_USB_Device_Library\Class\msc\inc;.\Usb\STM32_USB_Device_Library\Core\inc;.\Usb\USB_APP;.\System\inc;.\User\recgimg;.\User\fdcolor;.\AddedHeader
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ./User/: main.c
  group Hardware
    ./Hardware/src/: sd_card.c oledSPI.c Soft_IIC.c dev_mpu9250.c
  group FWLibrary
    ./FWLibrary/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group System
    ./System/src/: cfg_func_f407.c system_stm32f4xx.c startup_stm32f40_41xxx.s stm32f4xx_it.c
  group Fatfs
    ./Fatfs/: diskio.c ff.c fat_func.c
  group AddedHeader
    ./AddedHeader/: F4_pwm.c
